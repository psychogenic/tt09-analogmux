**************************************
* SPICE STIMULI FILE
* generated from
**************************************

Vsel0 sel0 0 PWL 0n 0 180n 0 181n VCC 200n VCC 201n 0 220n
+0 221n VCC
Vrsel2 rsel2 0 PWL 0n 0 100n 0 101n VCC
Vsel1 sel1 0 PWL 0n 0 200n 0 201n VCC
Vvres vres 0 PWL 0n VCC
Vvss vss 0 PWL 0n 0
Ven_counter en_counter 0 PWL 0n VCC
Vvcc vcc 0 PWL 0n VCC
Ven_ring en_ring 0 PWL 0n VCC
Vrsel0 rsel0 0 PWL 0n 0 40n 0 41n VCC 60n VCC 61n 0 80n
+0 81n VCC 100n VCC 101n 0 120n 0 121n VCC 140n VCC 141n 0
+160n 0 161n VCC
Vrsel1 rsel1 0 PWL 0n 0 60n 0 61n VCC 100n VCC 101n 0 140n
+0 141n VCC
