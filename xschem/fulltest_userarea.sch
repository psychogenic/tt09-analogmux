v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/ttuser/vmswap/tt09-analogmux/xschem/muxtest.sym} 220 -140 0 0 {name=x1}
C {/home/ttuser/vmswap/tt09-analogmux/xschem/ringtest.sym} 230 -360 0 0 {name=x2}
C {devices/lab_pin.sym} 80 -410 0 0 {name=p1 lab=select0}
C {devices/lab_pin.sym} 80 -330 0 0 {name=p2 lab=VDD}
C {devices/lab_pin.sym} 80 -390 0 0 {name=p3 lab=select1}
C {devices/lab_pin.sym} 80 -310 0 0 {name=p4 lab=VSS}
C {devices/lab_pin.sym} 380 -410 0 1 {name=p5 lab=ring_out
}
C {devices/lab_pin.sym} 80 -370 0 0 {name=p6 lab=enable_ring}
C {devices/lab_pin.sym} 80 -350 0 0 {name=p7 lab=enable_counter}
C {devices/lab_pin.sym} 70 -210 0 0 {name=p8 lab=VDD}
C {devices/lab_pin.sym} 70 -190 0 0 {name=p9 lab=VSS}
C {devices/lab_pin.sym} 70 -170 0 0 {name=p10 lab=VRES}
C {devices/lab_pin.sym} 70 -150 0 0 {name=p11 lab=select0
}
C {devices/lab_pin.sym} 70 -130 0 0 {name=p12 lab=select1}
C {devices/lab_pin.sym} 70 -110 0 0 {name=p13 lab=rsel0}
C {devices/lab_pin.sym} 70 -90 0 0 {name=p14 lab=rsel1}
C {devices/lab_pin.sym} 70 -70 0 0 {name=p15 lab=rsel2}
C {devices/lab_pin.sym} 370 -210 0 1 {name=p16 lab=muxtest_out
}
C {devices/lab_pin.sym} 370 -190 0 1 {name=p17 lab=ladderout}
C {devices/ipin.sym} 100 -670 0 0 {name=p18 lab=VDD}
C {devices/ipin.sym} 100 -640 0 0 {name=p19 lab=VSS}
C {devices/ipin.sym} 380 -680 0 0 {name=p20 lab=select0}
C {devices/ipin.sym} 380 -660 0 0 {name=p21 lab=select1}
C {devices/ipin.sym} 380 -630 0 0 {name=p22 lab=rsel0}
C {devices/ipin.sym} 380 -610 0 0 {name=p23 lab=rsel1}
C {devices/ipin.sym} 380 -590 0 0 {name=p24 lab=rsel2}
C {devices/ipin.sym} 380 -560 0 0 {name=p25 lab=enable_ring}
C {devices/ipin.sym} 380 -540 0 0 {name=p26 lab=enable_counter}
C {devices/opin.sym} 620 -640 0 0 {name=p27 lab=ring_out}
C {devices/opin.sym} 620 -610 0 0 {name=p28 lab=muxtest_out}
C {devices/opin.sym} 620 -580 0 0 {name=p29 lab=ladderout}
C {devices/ipin.sym} 690 -700 0 0 {name=p30 lab=VRES}
